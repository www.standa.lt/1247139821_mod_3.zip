# Autodesk Inventor part: 7T38
## iProperties
Created: 2008-09
Part Number: 7T38
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
